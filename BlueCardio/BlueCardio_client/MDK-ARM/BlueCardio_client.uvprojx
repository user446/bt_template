# Keil uVision project BlueCardio_client.uvprojx, settings and files
target Client (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BlueCardio_client +hex
  AfterMake: fromelf.exe --bin Objects\BlueCardio_client.axf --output Objects\BlueCardio_client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION THROUGHPUT_TEST_SERVER=0 THROUGHPUT_TEST_CLIENT=0 UART_BAUDRATE=115200 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c include: ..\inc;..\Library\hal\inc;..\Library\BlueNRG1_Periph_Driver\inc;..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\Library\CMSIS\Include;..\Library\Bluetooth_LE\inc;..\Library\BLE_Application\layers_inc;..\Library\BLE_Application\Utils\inc;..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group HAL
    ../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c
  group Library
    ../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Config.c SDK_EVAL_Com.c SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Stack
    ../Library/cryptolib/: libcrypto.a
    ../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../src/: BlueNRG1_it.c gatt_db.c throughput.c BlueCardio_main.c
