# Keil uVision project BLE_Chat.uvprojx, settings and files
target Client (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Chat_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\BLE_Chat_Client.axf --output Client\Objects\BLE_Chat_Client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c include: ../../inc;..\..\Library\hal\inc;..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\Library\CMSIS\Include;..\..\Library\Bluetooth_LE\inc;..\..\Library\BLE_Application\layers_inc;..\..\Library\BLE_Application\Utils\inc;..\..\Library\BLE_Application\OTA\inc;..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group HAL
    ../../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c
  group Library
    ../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group OTA
    ../../Library/BLE_Application/OTA/src/: OTA_btl.c
  group Platform_Layers
    ../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../Library/cryptolib/: libcrypto.a
    ../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Chat_main.c BlueNRG1_it.c chat.c
    ../src/: template_main.c server_app.c
  group Inc
    ../inc/: app_state.h BlueNRG1_conf.h BlueNRG1_it.h gatt_db.h template.h Template_config.h
target Server (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_Chat_Server +hex
  AfterMake: fromelf.exe --bin Server\Objects\BLE_Chat_Server.axf --output Server\Objects\BLE_Chat_Server.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c include: ..\..\inc;..\..\Library\hal\inc;..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\Library\CMSIS\Include;..\..\Library\Bluetooth_LE\inc;..\..\Library\BLE_Application\layers_inc;..\..\Library\BLE_Application\Utils\inc;..\..\Library\BLE_Application\OTA\inc;..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group added to the first target's files
    ../../src/: gatt_db.c
  group left out of the first target's files
    ../inc/: BlueNRG1_conf.h BlueNRG1_it.h Template_config.h app_state.h gatt_db.h template.h
    ../src/: server_app.c template_main.c
